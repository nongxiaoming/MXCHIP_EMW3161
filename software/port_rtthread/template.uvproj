# Keil uVision project template.uvproj, settings and files
target RT-Thread EMW316x (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1
  c define: EMW3161 USE_STDPERIPH_DRIVER STM32F2XX
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
